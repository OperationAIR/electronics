# Repository OperationAIR/electronics

File README.md:

# Electronics and firmware for Operation Air Ventilator

The electronics for the Operation Air AIROne is comprised of a custom developed PCB with a LPC11U37 microcontroller stacked on top of a Raspberry Pi 4 (Model B).

This repository contains the electronic designs for the PCB and the accompanying firmware.

The Pi talks to the microcontroller over UART using a [custom binary protocol](firmware/README.md#uart-communication-protocol).

Contact info@interay.com for assembled, tested and programmed ready for use boards.

## License

Copyright (c) 2020 TU Delft. All rights reserved.

Licensed under the [Apache 2.0](LICENSE) license.

## KiCad design pcb/7001-mainboard/7001-ventilator_mainboard.kicad_pcb

Parts:
C1, C2, C3, C15, C21, C23, C28, C29, C43, C49, C50: 100nF; C_0805_2012Metric
C4, C11, C52: 1uF; C_0805_2012Metric
C7, C20, C40: 2.2nF; C_0805_2012Metric
C10, C12: 18pF; C_0805_2012Metric
C13: 4.7uF; C_0805_2012Metric
C14, C18, C24, C26, C38, C41, C42, C44: 10uF 50V; C_1210_3225Metric
C16, C25, C53: 10uF; C_0805_2012Metric
C17, C27, C45: 2.2nF 50V; C_0805_2012Metric
C19, C39, C48, C51, C54: 100nF 50V; C_0805_2012Metric
C22: 330uF; CP_Elec_12.5_MAL214699107E3; MPN MAL214699107E3
C46, C47: 10nF 100V; C_1206_3216Metric; MPN 885012208112
D1, D2, D11: D_Schottky; D_SOD-123F; MPN NRVTS245ESFT3G
D3: S5MB R5G 100V; D_SMB; MPN S5MB R5G
D4: D_TVS; WE-TVSP_TVS_DIODE; MPN 824501301; Farnell 2536572
D5, D6, D7, D8, D9: Green; LED_0805_2012Metric; MPN KP-2012LSGC; Farnell 2463991
D10: Red; LED_0805_2012Metric; MPN KPT-2012EC; Farnell 2099236
FB1, FB2: BLM18HE601SN1D; L_0603_1608Metric; MPN BLM18HE601SN1D; Farnell 2443238
FID1, FID2, FID3, FID4, FID5: DNI; Fiducial_1mm_Mask2mm
FL1: 744282010; L_CommonMode_Wuerth_WE-SCC; MPN 744282010
H1, H2, H7: DNI (mounting hole); MountingHole_2.7mm_M2.5_Pad__wavesolder
H3: DNI; MountingHole_2.7mm_M2.5_Pad__wavesolder
H4, H5, H6: DNI; MountingHole_2.7mm_M2.5__wavesolder
J1: USB_B_Micro; USB_Micro-B_Molex_47346-0001; MPN 47346-0001; Farnell 1568026
J2, J7: 6-pin FFC connector; Hirose_FH12-6S-0.5SH_1x06-1MP_P0.50mm_Horizontal; MPN FH12-6S-0.5SH; Farnell 1324538
J3, J4, J13, J14: 2-pin screw terminal; TerminalBlock_Wurth_WR-TBL_691322110002_1x02_P3.50mm_Horizo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; MPN 691322110002; Farnell 1841315
J5: 5-pin screw terminal vertical; TerminalBlock_Wurth_WR-TBL_691321100005_1x05_P3.50mm_Vertic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; MPN 691321100005
J6: 5V out; PinHeader_1x05_P2.54mm_Vertical
J8, J11: 5-pin screw terminal; TerminalBlock_Wurth_WR-TBL_691322110005_1x05_P3.50mm_Horizo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; MPN 691322110005
J9: Raspberry_Pi_2_3; PinSocket_2x20_P2.54mm_Vertical_holes_SMD; MPN REF-182665-01
J10: 6-pin header; PinHeader_1x06_P2.54mm_Vertical
J15: 2x10-pin header; PinHeader_2x10_P2.54mm_Vertical_SMD; MPN 61032021121
J16: 10-pin SWD header; connector_jtag_10pin_shrouded; MPN 20021521-00010T1LF
LOGO1: LOGO; JitterLogo
LOGO2: LOGO; OperationAir260
Q1: NX3020NAKV,115; SOT-666; MPN NX3020NAKV,115; Farnell 2311182
R3, R12, R22, R23, R24: 1k5; R_0805_2012Metric
R4, R5: 33R; R_0805_2012Metric
R6, R11, R15, R18, R35, R39: 10k; R_0805_2012Metric
R7, R30: DNI; R_0805_2012Metric
R8, R9, R16, R17: 0; R_0805_2012Metric
R10, R31: 68k; R_0805_2012Metric
R14, R33: 100k; R_0805_2012Metric
R19, R29, R37, R38, R40, R44, R45, R46: 3.3k; R_0805_2012Metric
R21, R32, R34, R36: 4.7k; R_0805_2012Metric
R41, R42, R43, R49, R50: 150; R_0805_2012Metric
R47: 150 1%; R_0805_2012Metric
R48: 2.32k 1%; R_0805_2012Metric
RV1: Varistor; WE_VS_Varistor; MPN 82551250
TP1, TP4, TP5, TP6, TP7: DNI; TestPoint_THTPad_D1.5mm_Drill0.7mm
U2: TPD2E2U06; SOT-553; MPN TPD2E2U06DRLR; Farnell 3116500
U3: LPC11U37FBD48-401_; LQFP-48_7x7mm_P0.5mm; MPN LPC11U37FBD48/401; Farnell 2115662
U4: MCP1825S-3302E; SOT-223-3_TabPin2; MPN MCP1825S-3302E; Farnell 1578404
U5: S24SE05004PDFA_DC-DC; DCDC-5V_S24SE05004PDFA; MPN S24SE05004PDFA; Mouser 108-S24SE05004PDFA
U6, U15: MCP4725; SOT-23-6; MPN MCP4725A1T-E/CH; Farnell 2774927
U7, U13, U14: ITS4142NHUMA1; SOT-223; MPN ITS4142NHUMA1
U16: LD1086DTTR; TO-252-2; MPN LD1086DTTR (adjustable)
Y1: 12MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm; MPN 7M-12.000MEEQ-T; Farnell 2308719

Connections:
+3V3: C2.1, C3.1, C4.1, C25.1, C49.1, C52.1, FB2.2, J15.18, J15.20, J16.1 (VTref), Q1.2 (G), Q1.5 (G), R3.2, R15.1, R23.2, R35.2, R37.2, R39.2, R41.2, R44.2, TP5.1, U3.8 (VDD), U3.44 (VDD), U4.3 (VO); also elsewhere on the board
+5V: C1.1, C11.1, C13.1, C16.1, C23.1, C28.1, C29.1, J6.5, J9.2 (5V), J9.4 (5V), R7.2, R45.2, R46.2, TP1.1, U4.1 (VI), U5.6 (+VOUT), U6.3 (VDD), U15.3 (VDD), U15.6 (A0); also elsewhere on the board
+24V: C14.1, C18.1, C22.1, C24.1, C26.1, C41.1, C42.1, C44.1, D3.1 (K), FB1.2, J8.5, J11.5, R6.2, R11.2, TP4.1, U5.1 (+VIN), U7.4 (IN), U13.4 (IN), U14.4 (IN)
/24_CHOKE: C47.1, D3.2 (A), FL1.4
/A_MFC_FEEDBACK_AIR: C40.1, R31.1, R33.2, TP7.1, U3.35 (PIO0_14)
/A_MFC_FEEDBACK_O2: C20.1, R10.1, R14.2, TP6.1, U3.34 (PIO0_13)
/A_MFC_PRESSURE: U3.33 (PIO0_12); also elsewhere on the board
/A_PSENSE_3: U3.32 (PIO0_11); also elsewhere on the board
/BATT_LEVEL: C43.1, R11.1, R24.2, U3.42 (PIO0_23)
/EXHALE_PWM: R34.2, U3.30 (PIO0_22), U13.3 (ON)
/EXHALE_VALVE: C17.1, D1.1 (K), J13.2, R38.2, U13.1 (OUT)
/EXTRA_PWM: R32.2, U3.36 (PIO1_13), U7.3 (ON)
/EXTRA_VALVE: C27.1, D11.1 (K), J4.2, R19.2, U7.1 (OUT)
/FLOW_I2C_SCL: J2.3, J7.3, R49.1
/FLOW_I2C_SDA: J2.4, J7.4, R50.2
/I2C_3V3_SCL: Q1.1 (S), R37.1, R49.2, U3.15 (PIO0_4)
/I2C_3V3_SDA: Q1.4 (S), R44.1, R50.1, U3.16 (PIO0_5)
/I2C_5V_SCL: Q1.6 (D), R45.1, U6.5 (SCL), U15.5 (SCL)
/I2C_5V_SDA: Q1.3 (D), R46.1, U6.4 (SDA), U15.4 (SDA)
/INHALE_PWM: R36.2, U3.37 (PIO1_14), U14.3 (ON)
/INHALE_VALVE: C45.1, D2.1 (K), J14.2, R40.2, U14.1 (OUT)
/LED_ERROR: R43.2, U3.17 (PIO0_21)
/LED_STATUS: R42.2, U3.18 (PIO1_23)
/MCU_DM: R5.2, U3.19 (USB_DM)
/MCU_DP: R4.2, U3.20 (USB_DP)
/MCU_IO_1: J15.16, U3.40 (PIO0_16)
/MCU_IO_2: J15.14, U3.26 (PIO1_21)
/MCU_IO_3: J15.12, U3.25 (PIO1_31)
/MCU_IO_4: J15.10, U3.24 (PIO1_28)
/MFC_SETPOINT_AIR: J11.3, U15.1 (VOUT)
/MFC_SETPOINT_O2: J8.3, U6.1 (VOUT)
/POWER_STATUS_DISCHARGING: C15.1, R12.2, U3.22 (PIO0_6)
/POWER_STATUS_FAIL: C50.1, R22.2, U3.23 (PIO0_7)
/PSENSE_1_DATA_READY: U3.48 (PIO1_16); also elsewhere on the board
/PSENSE_1_SPI_~CS~: U3.2 (PIO1_19); also elsewhere on the board
/PSENSE_2_DATA_READY: U3.43 (PIO1_15); also elsewhere on the board
/PSENSE_2_SPI_~CS~: U3.38 (PIO1_22); also elsewhere on the board
/PSENSE_RESET: U3.13 (PIO1_20); also elsewhere on the board
/PSENSE_SPI_CLK: U3.31 (PIO1_29); also elsewhere on the board
/PSENSE_SPI_MISO: U3.27 (PIO0_8); also elsewhere on the board
/PSENSE_SPI_MOSI: U3.28 (PIO0_9); also elsewhere on the board
/PWR+: C46.1, D4.2 (A2), FL1.2, J5.2, RV1.1
/PWR-: C46.2, D4.1 (A1), FL1.1, J5.1, RV1.2
/RPI_IO_1: J9.38 (GPIO20/MOSI1), J15.4
/RPI_IO_2: J9.37 (GPIO26), J15.2
/RPI_ON_OFF: J9.5 (SCL/GPIO3), U3.45 (PIO0_17)
/RPI_RX: J9.10 (GPIO15/RXD), R17.2
/RPI_TX: J9.8 (GPIO14/TXD), R16.2
/RPI_~ISP~: J9.11 (GPIO17), R9.2
/RPI_~RST~: J9.36 (GPIO16), R8.2
/SWCLK: J16.4 (SWDCLK/TCK), U3.29 (PIO0_10)
/SWDIO: J16.2 (SWDIO/TMS), U3.39 (PIO0_15)
/UART_RX: J10.4, R16.1, U3.46 (PIO0_18)
/UART_TX: J10.5, R17.1, U3.47 (PIO0_19)
/UPS_3V3_PU: J5.3, R23.1
/UPS_DISCHG: J5.4, R12.1
/UPS_FAIL: J5.5, R22.1
/USB_DN: J1.2 (D-), R5.1, U2.2 (NC), U2.5
/USB_DP: J1.3 (D+), R3.1, R4.1, U2.3
/USB_VBUS: J1.1 (VBUS), R21.2, U3.14 (PIO0_3)
/USER_SWITCH: C21.1, R18.2, U3.21 (PIO1_24)
/V_flow_3v3: C48.1, C53.1, C54.1, FB2.1, J2.6, J7.6
/V_flow_heater: C38.1, C39.1, C51.1, J2.1, J7.1, R47.2, U16.2 (OUT)
/XTAL_IN: C10.1, U3.6 (XTALIN), Y1.1
/XTAL_OUT: C12.1, U3.7 (XTALOUT), Y1.3
/~ISP~: J15.6, R9.1, R35.1, U3.4 (PIO0_1)
/~RESET~: C7.1, J15.8, J16.10 (~RESET~), R8.1, R39.1, U3.3 (PIO0_0)
GND: C1.2, C2.2, C3.2, C4.2, C7.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, D1.2 (A), D2.2 (A), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.2 (A), FL1.3, H1.1, H2.1, H3.1, H7.1, J1.5 (GND), J1.6 (Shield), J2.2, J2.5, J2.MP (MountPin), J3.1, J4.1, J6.1, J7.2, J7.5, J7.MP (MountPin), J8.1, J8.4, J9.6 (GND), J9.9 (GND), J9.14 (GND), J9.20 (GND), J9.25 (GND), J9.30 (GND), J9.34 (GND), J9.39 (GND), J10.1, J11.1, J11.4, J13.1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; also elsewhere on the board
unnamed: C19.1, FB1.1, U16.3 (IN)
unnamed: D5.2 (A), R19.1
unnamed: D6.2 (A), R38.1
unnamed: D7.2 (A), R40.1
unnamed: D8.2 (A), R41.1
unnamed: D9.2 (A), R42.1
unnamed: D10.2 (A), R43.1
unnamed: J3.2, R15.2, R18.1
unnamed: J8.2, R10.2
unnamed: J11.2, R31.2
unnamed: R6.1, R29.2, U5.3 (ON_OFF)
unnamed: R7.1, R30.2, U5.5 (TRIM)
unnamed: R47.1, R48.2, U16.1 (ADJ/GND)

Notes on the sheet:
5V header for RPI display
5V -> 3.3V
24VDC 4A
24V -> 5V 3A
24V power input
Power
Pressure sensor(s)
optional output voltage trim
3x 24V Valve
Input filter + reverse polarity protection
Required: - 12-24V 6W 50mv rms - 3.3V 25mv rms
3.3V -1%/+5% 50mA 20mv rms
Valves are driven with 24V PWM signal
Place close to ADC input
2x Mass Flow Controller
2x Flow Sensor
RPI Connector
Signal will be connected by UPS relay Series resistor for robustness + filtering
TODO SETPOINT_OUT robustness: ESD/SURGE PROTECTION?
Strong pulldown: overrule mcu internal pullups to avoid glitch at power-on
SCK1
MOSI_1
MISO_1
SCK0
MISO_0
MOSI_0
adc
Extra I/O
Power / status LEDS
Should be compatible with TTL-232R-3V3 Note: are TX/RX correct?
CT16B0_MAT0
CT16B1_MAT1
CT16B0_MAT1
RPI mounting
Debug: SWD + UART
ADC
USB
(reset)
(boot_USB)
(boot_~ISP~)

Parts:
C5, C6, C36: 1nF; C_0805_2012Metric
C8, C9, C31, C33: 100nF; C_0805_2012Metric
C30, C32: 1uF; C_0805_2012Metric
C34: 470pF; C_0805_2012Metric
C35, C37: 2.2nF; C_0805_2012Metric
R1, R2: 68k; R_0805_2012Metric
R13, R20: 100k; R_0805_2012Metric
TP2, TP3: DNI; TestPoint_THTPad_D1.5mm_Drill0.7mm
U1, U8: MPRLS0001PG0000SA; MPN MPRLS0001PG0000SA; Digikey 480-7100-1-ND
U9: ABPDXXX000XXAX5; ABPDXXX000XX0XX; MPN ABPDANT015PGAA5; Digikey 480-6253-ND
U11: MPVZ5010GW6U; MPN MPVZ5010GW6U

Connections:
+3V3: C8.2, C9.2, U1.12 (Vcc), U8.12 (Vcc); also elsewhere on the board
+5V: C30.1, C31.1, C32.1, C33.1, U9.6 (Vcc), U11.2 (Vcc); also elsewhere on the board
/A_MFC_PRESSURE: C37.1, R2.1, R13.2, TP3.1; also elsewhere on the board
/A_PSENSE_3: C35.1, R1.1, R20.2, TP2.1; also elsewhere on the board
/PSENSE_1_DATA_READY: U1.8 (EOC); also elsewhere on the board
/PSENSE_1_SPI_~CS~: U1.1 (SS); also elsewhere on the board
/PSENSE_2_DATA_READY: U8.8 (EOC); also elsewhere on the board
/PSENSE_2_SPI_~CS~: U8.1 (SS); also elsewhere on the board
/PSENSE_RESET: U1.9 (RES), U8.9 (RES); also elsewhere on the board
/PSENSE_SPI_CLK: U1.3 (SCK), U8.3 (SCK); also elsewhere on the board
/PSENSE_SPI_MISO: U1.7 (MISO), U8.7 (MISO); also elsewhere on the board
/PSENSE_SPI_MOSI: U1.2 (MOSI), U8.2 (MOSI); also elsewhere on the board
/pressure_sensor/MPVZ5010_OUT: C34.1, R1.2, U11.4 (Vout)
GND: C8.1, C9.1, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, R13.1, R20.1, U1.10 (GND), U8.10 (GND), U9.1 (GND), U11.3 (GND); also elsewhere on the board
unnamed: C5.1, U1.4 (VO+)
unnamed: C5.2, U1.6 (VO-)
unnamed: C6.1, U8.4 (VO+)
unnamed: C6.2, U8.6 (VO-)
unnamed: C36.1, R2.2, U9.3 (VOUT)

Notes on the sheet:
Pressure after patient (0-70mbar)
Pressure before patient (0-70mbar)
Pressure sensor 2 (after patient)
Pressure sensor 1 (before patient)
SPI bus shared between sensor 1/2
Pressure sensor 3 (weaning)
Pressure close to patient (0-70mbar)
Place close to ADC input
5V to 3V divider + RC filter: Fc = 1.8Khz
Pressure vessel between MFC and pressure regulator (0.5-1 bar)
Pressure sensor 4 (MFC output)

Board: 2 copper layers, 99.0 x 110.5 mm, 167 parts (0 on the bottom side), 87 nets.

## Commit log (part)

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2020-03-21 First start of schematic design
2020-03-21 Cleanup first design
2020-03-21 Add 0-20mA for pressure regulator
    The pressure regulator can be adjusted via 4-20mA (SPI via AD5410)
    The regulator has an on-board pressure sensor giving 4-20mA feedback, which
    we convert to 0.6-3.0V for the ADC.
2020-03-22 Schematics: add pressure sensors
    The design allows 2 pressure sensors: 'sensor 1' and 'sensor 2'.
    Only sensor 1 is required. Sensor 2 can be left out, but may be placed in case of
    changing requirements in the future (e.g. using 2 sensors to measure
    flow).
    Each of the sensors may be implemented by choosing one of 3 different footprints.
    On the PCB layout, these 3 footprints will be overlapped to create a
2020-03-22 Schematics/PCB: add screw terminal footprints
2020-03-22 Add cmsis_dsp_lib dependency for pid controller
2020-03-23 Schematics: add 24v,12v power supplies, etc
2020-03-23 schematics: ready for review?
2020-03-23 update bom with ordernumbers
2020-03-24 Add non-pcb parts (connector mating parts) to BOM
2020-03-24 Update schematics based on more feedback
2020-03-24 update schematics from feedback
2020-03-24 Sync design with BOM
2020-03-24 add readme file
2020-03-24 Finalize BOM, add all footprints
2020-03-24 Echo back settings
2020-03-24 BAUDRATE back to 115200
2020-03-24 PCB: route bottom half
2020-03-24 update layout
2020-03-24 layout: everything except pressure sensors
2020-03-24 PCB: Finish layout
2020-03-24 PCB: final BOM (1x 100nf removed)
2020-03-25 PCB: add production files (gerber)
2020-03-25 Firmware: remove non-existing 'RGB'
2020-03-25 add settings struct
    These are the settings that will be passed down from the raspberry pi.
    This will probably change in the near future.
2020-03-25 Remove usb mass storage driver: only cdc
2020-03-25 Firmware: strip more obsolete code, start implementing analog sensors
    The scale factor for the flow sensor & DPR are not entirely clear:
    - The flow sensor was assumed to be ratiometric, but the datasheet shows
    a table from 1-5V. We should probably assume the table to be correct.
    - What is the DPR range? Also, is it 0-20mA or 4-20mA?
2020-03-25 Firmware: fix reliability issue by upgrading libraries
2020-03-26 Revert "Merge 'board_config'"
    This reverts commit ff83990df67a0bb2994b00c9bb8aaf5a0e8a4da0, reversing
    changes made to 7acdfaee9a63d0f7a54f232d340b9122f2a7cf64.
2020-03-26 board support: remove obsolete stuff
2020-03-26 board support: remove more obsolete stuff
2020-03-26 Fix board support for lpc11uxx devboard
    The devboard needs P1_24 low to enable the USB D+ pullup
2020-03-26 Add utility functions to enable status+error leds
2020-03-26 Firmware: cleanup irrelevant code
2020-03-26 Schematics: add pressure sensor datasheet
2020-03-27 Firmware: add driver for DPR DAC
2020-03-27 fix typo
2020-03-27 Add data_ready pin for mprl driver
2020-03-27 Add reset pin to MPRL driver
2020-03-27 Create pi_communication module
    To abstract away the uart communication between rpi and lpc. It is a
    binary protocol that works by matching a magic 4-byte sequence at the
    beginning of the command.
2020-03-27 Add gitignores
2020-03-27 Add bounds check to settings.
    Settings should always fall withn predefined sane bounds.
2020-03-27 First test demo: DPR control based on pressure
2020-03-28 Bugfix: DPR scale factor incorrect
2020-03-28 Control loop fom 1khz to 500Hz
2020-03-28 Working driver for MPRLS pressure sensor (read blocking)
2020-03-28 Clean up pressure sensor branch
2020-03-28 Bugfix: cli shows sensor1 values at pressure sensor 2
2020-03-28 Fix scale factors, filter pressure sensors
2020-03-28 Move uart stuff to pi_communication module
2020-03-28 Add i2c DAC example in main
2020-03-29 Fix uart transfer by invoking isr manually.
2020-03-29 Add pi_comm_send_string function and send 'sane' settings
2020-03-29 Add dpr stop function, hardcoded flow controller
2020-03-29 Implement command to read all sensor data
2020-03-29 Add more serial commands, led on, led off, get-sensors
2020-03-29 DPR driver: send PWM instead of 4-20mA
2020-03-29 Bugfix: cli cmd 'DPR stop' implemented incorrectly
2020-03-29 disable verbose debug statement
2020-03-30 Add new settings fields
2020-03-30 Remove tidal volume settings.
2020-03-30 Tuned PWM PID loop
2020-03-30 Send back settings to host
2020-03-31 Add first support for MFC control loop
2020-03-31 Add code for MFC pressure sensor
2020-03-31 Add basic readme with build instructions
2020-03-31 Add uart pinout img
2020-03-31 Fix crc16_usbchecksum: need to init withh 0xFFFF.
2020-03-31 CLI: cleanup, add PID tune commands for MFC
2020-03-31 prepare for I2C flow sensor
    Code works, but for niw it is hacked into the i2c_dac module.
    Needs to be factored out for better maintainability
2020-03-31 Implement MPRLS pressure sensors in control loop
    Note: calibration / verification with the actual system is TBD.
2020-03-31 Cleanup user settings
2020-03-31 Tweak calibration time
2020-03-31 Refactor flow sensors
2020-03-31 Fix analog sensor
2020-03-31 No MPRLS when using analog sensors
2020-04-01 Adapt to new settings, fix potential underflow in MPRLS driver
2020-04-01 PWM output to dampen the shock wave
2020-04-01 Start/Stop from gui settings
2020-04-01 Apply all GUI settings (TODO: test)
2020-04-01 Flowsensor: disable debug prints
2020-04-01 Send dummy pressure data on the 'flow' channel to test python GUI
2020-04-02 Bugfix: UART infinite loop
2020-04-02 Update pi command values
2020-04-02 Configure for digital pressure sensors
2020-04-02 Update baudrate to 500000 and PiCommandSensor values
    NB: Use with latest python code (#18a38114b99ef)
2020-04-03 PCB: update BOM
2020-04-03 PCB: schematics for V2
2020-04-03 Update schematics (PSU connector) + BOM
2020-04-03 Add debug print for MPC pressure
2020-04-03 Add i2c flow sensor, but divide sample rate for by 5.
    Seems like 500Hz was too fast in combination with the current code.
2020-04-03 Add content to Readme
2020-04-03 PCB: layout in progress
2020-04-03 PCB layout: position of components near-final
2020-04-03 PCB layout: DRC pass
2020-04-03 PCB: final BOM
2020-04-03 PCB: improve silkscreen, mounting holes
2020-04-03 PCB: layout + BOM + Gerbers ready for review
2020-04-04 Only try to match uart command if buffer has 4 or more bytes
2020-04-05 Flow sensor added, I2C communication restored
2020-04-05 Add breath cycle state to sensor data (Peak pressure/PeeP)
2020-04-05 Fix critical bug: reading multiple elements from ringbuffer
    Reading from current read pointer is not guaranteed. Next element may be
    wrapped around to begining of the buffer.
2020-04-05 Remove obsolete code, add comments
2020-04-05 Implement tidal volume and oxygen 'sensors' [UNTESTED]
2020-04-05 sensors: add MFC feedback
2020-04-06 Inspiratory
2020-04-06 Refactor sensors, send all available sensor data to RPI
2020-04-06 Implement minute volume (in mL per minute)
2020-04-06 Fix complile error
2020-04-06 Turn off status LED when aborting calibration
2020-04-06 PID loop Expiratory valve
2020-04-06 Fix markdown links
2020-04-06 Update MFC docs
2020-04-06 Remove support for obsolete analog pressure sensors
2020-04-06 Add board support for hardware V1
2020-04-06 Add more docs
2020-04-06 Add docs
2020-04-06 Fix uart byte codes
2020-04-06 Add inspiratory hold commands to pi_communication
2020-04-07 Pi communication: implement most test commands
2020-04-07 Pi communication: implement PiCommandRequestSettings
2020-04-07 Fix the pressure sensor saturation.
2020-04-07 Change ascii responses for switches
2020-04-07 Rename valves to insp and exp valves.
2020-04-07 Add PID tune through Serial commands
2020-04-08 Add tidal_volume_inhale to sensordata
2020-04-08 Add inspiratory hold to sensor ata sent to Pi
2020-04-08 Cleanup I2C code
2020-04-08 Add profiling to review performance
2020-04-08 Control loop dt to 5ms (200Hz)
2020-04-08 Minor refactor: split sensors_update in functions
2020-04-09 cleanup profiling
2020-04-09 Add self-test, rename insp and exp pressure sensors correctly.
2020-04-09 Update docs about sensor data
2020-04-09 i2c pullup
2020-04-09 Add UPS status info + battery level
    NOTE: this will only work on PCB V1+
2020-04-09 App: cleanup obsolete start/stop requested
2020-04-09 Add pi-commands to trigger expiratory hold. Change docs.
2020-04-09 Fix the docs for exp manoeuvre
2020-04-09 Fix board config for PCB V1
2020-04-09 Add CLI command for extra valve
2020-04-09 New PID values
2020-04-09 Fix flow sensor includeS
2020-04-10 Fix typo bug
2020-04-10 Calibrate MFC pressure sensor
    This calibration is approximately correct between 0.5-1 bar.
    Somehow the sensor gives a large offset at P=0.
2020-04-10 CLI: show oxygen percentage
2020-04-10 Fix oxygen for board V1
    Oxygen / air ADC channels were swapped
2020-04-10 FW: Remove obsolete TODO comment
2020-04-11 Disable reset pin during breathing program
    This prevents raspberry pi from resetting the microcontroller for
    example during rpi (re)boot when breathing is running.
2020-04-11 Pass real hw version to app, even though it is not used yet
2020-04-11 Remove communication_test and add img dir
2020-04-11 Firmware robustness: add error handling, cleanup obsolete TODOs
2020-04-11 Refactor I2C: timeouts on potentially stalling operations
2020-04-11 Cleanup obsolete code / comments
2020-04-11 pi communication: simplify pi_comm_send
    Note: this should be tested to verify correctness..
2020-04-12 Cleanup EEPROM and unused 'stats' code
2020-04-12 Update documentation about system_status
2020-04-12 Refactor EEPROM storage
2020-04-12 Save & restore settings from EEPROM upon unexpected reset
2020-04-13 Bugfix: storage init fail
2020-04-13 Implement PiCommandUserSwitchGet (see issue #19)
2020-04-13 Fix documentation about MFC*Get
2020-04-13 breaking change: settings do not include alarmsettings anymore
2020-04-13 CLI: show system status
2020-04-13 Bugfix: MPRLS sensors share reset signal
    On init, only reset once
2020-04-13 Improve error handling
2020-04-13 Bugfix: default settings need valid CRC
2020-04-15 Bugfix: fix UART transmit, use FIFO
2020-04-15 Add simple blinky project
2020-04-16 Bugfix: I2C robustness, update libraries
2020-04-16 Fix usb vcom port
2020-04-17 Attempt to improve I2C robustness
2020-04-19 Further improve I2C robustness
2020-04-22 CLI: fix manual start command
2020-04-22 CLI: add command 'UPS'
2020-04-22 Also restore config after reset from RPI/Blackmagic
2020-04-22 MFC overpressure detection
2020-04-22 Sensors: getter for MFC/patient pressure should be cheap
    Calculations are done once, getters simply return pre-calculated results
2020-04-22 Add offset for MFC loop.
2020-04-22 Change MFC const to #define
2020-04-23 Add disclaimer
2020-04-23 Firmware: remove obsolete TODOs
2020-04-23 Move offset calibration to system startup
    At power-on, the system performs offset calibration: all air is let out
    of the exhale valve to compensate for pressure sensor offsets.
    This is only done at power-on: if the system resets unexpectedly,
    the calibration is skipped in order to resume operation as quickly as
    possible.
2020-04-30 Fix the Exp PID loop: reference ramp added. Add a boundary on the DPR control loop. Add some cli commands to test the valves.
2020-05-01 Add License
2020-05-07 Fix the MPC PID values
